Commit message: new xacro

File: urdf_urls/fr3_link5.urdf (robot description, URDF)
Before this commit: robot fr3, 22 links, 21 joints
Links:
- link link5_skin: geometry visual mesh filename=package://gentact_ros_tools/meshes/skin/self-cap/link5_fanc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 scale=1 1 1
