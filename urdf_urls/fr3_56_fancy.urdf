Commit message: new xacro

File: urdf_urls/fr3_56_fancy.urdf (robot description, URDF)
Before this commit: robot fr3, 31 links, 30 joints
Links:
- link link6_skin: geometry visual mesh filename=package://gentact_ros_tools/meshes/skin/link6_fancy.stl scale=1 1 1
